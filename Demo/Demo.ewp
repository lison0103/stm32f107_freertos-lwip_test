# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; DEBUG
  ICCARM.CCIncludePath2: ; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F107_ETH_Driver\inc; ..\Third_Party\lwip_v1.3.2\src\include\; ..\Third_Party\lwip_v1.3.2\src\include\lwip; ..\Third_Party\lwip_v1.3.2\src\include\netif; ..\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\Third_Party\lwip_v1.3.2\port\STM32F107; ..\Third_Party\lwip_v1.3.2\port\STM32F107\FreeRTOS\; ..\Third_Party\FreeRTOS\source\portable\IAR\ARM_CM3; ..\Third_Party\FreeRTOS\source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: Demo.srec
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group FreeRTOS
    ../Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/inc
    ../Third_Party/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable
    ../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FWLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c
    ../Libraries/STM32F107_ETH_Driver/src/: stm32f107_eth.c
    ../Libraries/STM32F107_ETH_Driver/inc/: stm32f107_eth.h
  group LwIP/Api
    ../Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Core/IPv4
    ../Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../Third_Party/lwip_v1.3.2/port/STM32F107/FreeRTOS/: ethernetif.c ethernetif.h sys_arch.c sys_arch.h
  group User
    ./: bsp.c fonts.c fonts.h FreeRTOSConfig.h ili_lcd.c ili_lcd.h lwipopts.h main.c miniDebug.c miniDebug.h netconf.c printf-stdarg.c stm32_eth_bsp.c stm32f107_eth_conf.h
